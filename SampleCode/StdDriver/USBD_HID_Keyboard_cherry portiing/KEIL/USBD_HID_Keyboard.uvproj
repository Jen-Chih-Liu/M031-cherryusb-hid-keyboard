# Keil uVision project USBD_HID_Keyboard.uvproj, settings and files
target USBD_HID_Keyboard (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: USBD_HID_Keyboard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\CherryUSB\core;..\..\USBD_HID_Keyboard_cherry portiing;..\..\..\..\ThirdParty\CherryUSB\common;..\..\..\..\ThirdParty\CherryUSB\class\hid
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group User
    ../: main.c
    ../../../../ThirdParty/CherryUSB/class/hid/: usbd_hid.c
    ../../../../ThirdParty/CherryUSB/core/: usbd_core.c
    ../../../../ThirdParty/CherryUSB/port/nuvoton/: usb_dc_usbfs.c
    ../../../../ThirdParty/CherryUSB/demo/: hid_keyboard_template.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c gpio.c
